options:
  parameters:
    author: Manolis Surligas (surligas@gmail.com)
    description: Capture Meteor Samples
    generate_options: no_gui
    id: lrpt_demod_pi
    output_language: python
    run_options: run
    title: lrpt_demod_pi
  states: {}

blocks:
- name: audio_samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: clock_alpha
  id: variable
  parameters:
    value: '5e-3'
  states: {}
- name: decimation
  id: variable
  parameters:
    value: max(4,satnogs.find_decimation(audio_samp_rate, 2, audio_samp_rate))
  states: {}
- name: output_sampling_rate
  id: variable
  parameters:
    value: '156250'
  states: {}
- name: pll_alpha
  id: variable
  parameters:
    value: '2.3e-3'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: output_sampling_rate
  states: {}
- name: sps
  id: variable
  parameters:
    value: (samp_rate*1.0)/(symb_rate*1.0)
  states: {}
- name: symb_rate
  id: variable
  parameters:
    value: '72000'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '4000'
    rate: '1000e-4'
    reference: '0.5'
    type: complex
  states: {}
- name: analog_rail_ff_0
  id: analog_rail_ff
  parameters:
    hi: '1'
    lo: '-1'
  states: {}
- name: antenna
  id: parameter
  parameters:
    type: str
    value: '""'
  states: {}
- name: bb_freq
  id: parameter
  parameters:
    label: Baseband CORDIC frequency (if the device supports it)
    type: eng_float
    value: '0.0'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/amartino/Radio_Projects/SatNogs/meteor_ouput/ouput
    type: byte
  states: {}
- name: blocks_float_to_short_0
  id: blocks_float_to_short
  parameters:
    scale: '32767'
  states: {}
- name: blocks_short_to_char_0
  id: blocks_short_to_char
  parameters: {}
  states: {}
- name: bw
  id: parameter
  parameters:
    comment: |-
      The bandwidth should configure RF filters on some devices.
      Set to 0.0 for automatic calculation.
    label: Bandwidth
    type: eng_float
    value: '0.0'
  states: {}
- name: dc_removal
  id: parameter
  parameters:
    label: Remove automatically the DC offset (if the device support it)
    type: str
    value: '"False"'
  states: {}
- name: decoded_data_file_path
  id: parameter
  parameters:
    type: str
    value: '"/tmp/.satnogs/data/data"'
  states: {}
- name: dev_args
  id: parameter
  parameters:
    label: Device arguments
    type: str
    value: '""'
  states: {}
- name: deviation
  id: parameter
  parameters:
    label: FM deviation (Hz)
    type: eng_float
    value: 5e3
  states: {}
- name: digital_clock_recovery_mm_xx_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: clock_alpha
    gain_omega: clock_alpha**2/4.0
    mu: '0.5'
    omega: sps
    omega_relative_limit: '0.005'
    type: complex
  states: {}
- name: digital_constellation_soft_decoder_cf_1
  id: digital_constellation_soft_decoder_cf
  parameters:
    constellation: digital.constellation_calcdist(([-1-1j, -1+1j, 1+1j, 1-1j]), ([0, 1, 3, 2]), 4, 1).base()
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: pll_alpha
  states: {}
- name: doppler_correction_per_sec
  id: parameter
  parameters:
    type: intx
    value: '20'
  states: {}
- name: enable_iq_dump
  id: parameter
  parameters:
    type: intx
    value: '0'
  states: {}
- name: file_path
  id: parameter
  parameters:
    type: str
    value: '"test.wav"'
  states: {}
- name: gain
  id: parameter
  parameters:
    comment: |-
      Generic gain value. 
      Each Soapy module
      will try to linearize this
      value by properly setting
      the device specific gains.
    type: eng_float
    value: '0.0'
  states: {}
- name: gain_mode
  id: parameter
  parameters:
    comment: |-
      Set the gain mode of the Soapy.
      Can be "Overall", "Specific"
      or "Settings Field"
    type: str
    value: '"Overall"'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: iq_file_path
  id: parameter
  parameters:
    type: str
    value: '"/tmp/iq.dat"'
  states: {}
- name: lo_offset
  id: parameter
  parameters:
    comment: |-
      To avoid the SDR carrier at the DC
      we shift the LO a little further
    type: eng_float
    value: '0'
  states: {}
- name: max_modulation_freq
  id: parameter
  parameters:
    label: The highest frequency in the modulating signal
    type: eng_float
    value: 3e3
  states: {}
- name: other_settings
  id: parameter
  parameters:
    label: Soapy Channel other settings
    type: str
    value: '""'
  states: {}
- name: ppm
  id: parameter
  parameters:
    comment: |-
      The frequency correction in PPM
      to correct for a local oscillator frequency deviation
    type: eng_float
    value: '0'
  states: {}
- name: rigctl_port
  id: parameter
  parameters:
    type: intx
    value: '4532'
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.6'
    decim: '1'
    gain: '1'
    ntaps: '361'
    samp_rate: samp_rate
    sym_rate: symb_rate
    type: fir_filter_ccf
  states: {}
- name: rx_freq
  id: parameter
  parameters:
    type: eng_float
    value: 100e6
  states: {}
- name: samp_rate_rx
  id: parameter
  parameters:
    label: Device Sampling rate
    type: eng_float
    value: '0.0'
  states: {}
- name: satnogs_doppler_compensation_0
  id: satnogs_doppler_compensation
  parameters:
    compensate: '1'
    fine_correction: '0'
    lo_offset: lo_offset
    out_samp_rate: output_sampling_rate
    samp_rate: samp_rate_rx
    sat_freq: rx_freq
  states: {}
- name: satnogs_iq_sink_0
  id: satnogs_iq_sink
  parameters:
    activate: enable_iq_dump
    append: 'False'
    filename: iq_file_path
    scale: '16768'
  states: {}
- name: satnogs_tcp_rigctl_msg_source_0
  id: satnogs_tcp_rigctl_msg_source
  parameters:
    addr: '"127.0.0.1"'
    interval: int(1000.0/doppler_correction_per_sec) + 1
    mode: 'False'
    mtu: '1500'
    port: rigctl_port
  states: {}
- name: satnogs_waterfall_sink_0
  id: satnogs_waterfall_sink
  parameters:
    center_freq: rx_freq
    fft_size: '1024'
    filename: waterfall_file_path
    mode: '1'
    rps: '10'
    samp_rate: output_sampling_rate
  states: {}
- name: soapy_rx_device
  id: parameter
  parameters:
    type: str
    value: '"driver=invalid"'
  states: {}
- name: soapy_source_0_0
  id: soapy_source
  parameters:
    ant0: antenna
    args: dev_args
    balance0: '0'
    bw0: bw
    center_freq0: rx_freq - lo_offset
    correction0: ppm
    dc_offset0: '0'
    dc_removal0: dc_removal
    dev: soapy_rx_device
    devname: custom
    gain_mode0: gain_mode
    nco_freq0: bb_freq
    overall_gain0: gain
    samp_rate: samp_rate_rx
    sdrplay_biastee: 'True'
    settings0: other_settings
    stream_args: stream_args
    tune_args0: tune_args
    type: fc32
  states: {}
- name: stream_args
  id: parameter
  parameters:
    label: Soapy Stream arguments
    type: str
    value: '""'
  states: {}
- name: tune_args
  id: parameter
  parameters:
    label: Soapy Channel Tune arguments
    type: str
    value: '""'
  states: {}
- name: udp_IP
  id: parameter
  parameters:
    type: str
    value: '"127.0.0.1"'
  states: {}
- name: udp_port
  id: parameter
  parameters:
    type: intx
    value: '16887'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: doppler_corrected
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: doppler_corrected
  states: {}
- name: waterfall_file_path
  id: parameter
  parameters:
    type: str
    value: '"/tmp/waterfall.dat"'
  states: {}

connections:
- [analog_agc_xx_0, '0', root_raised_cosine_filter_0, '0']
- [analog_rail_ff_0, '0', blocks_float_to_short_0, '0']
- [blocks_float_to_short_0, '0', blocks_short_to_char_0, '0']
- [blocks_short_to_char_0, '0', blocks_file_sink_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', digital_constellation_soft_decoder_cf_1, '0']
- [digital_constellation_soft_decoder_cf_1, '0', analog_rail_ff_0, '0']
- [digital_costas_loop_cc_0, '0', digital_clock_recovery_mm_xx_0, '0']
- [root_raised_cosine_filter_0, '0', digital_costas_loop_cc_0, '0']
- [satnogs_doppler_compensation_0, '0', virtual_sink_0, '0']
- [satnogs_tcp_rigctl_msg_source_0, freq, satnogs_doppler_compensation_0, doppler]
- [soapy_source_0_0, '0', satnogs_doppler_compensation_0, '0']
- [virtual_source_0, '0', analog_agc_xx_0, '0']
- [virtual_source_0, '0', satnogs_iq_sink_0, '0']
- [virtual_source_0, '0', satnogs_waterfall_sink_0, '0']

metadata:
  file_format: 1
